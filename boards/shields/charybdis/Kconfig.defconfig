## boards/shields/charybdis/Kconfig.defconfig
```kconfig
if SHIELD_SHIELD_CHARYBDIS_LEFT

config ZMK_KEYBOARD_NAME
	default "charybdis_left"

endif
```
